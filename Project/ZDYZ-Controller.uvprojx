# Keil uVision project ZDYZ-Controller.uvprojx, settings and files
target ZDYZ-Controller (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F429IGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.15.0
  cpu: IRAM(0x20000000,0x00030000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: ZDYZ-Controller +hex
  c flags: Optim=1 OneElfS=1 uC99=1
  c define: USE_STDPERIPH_DRIVER,STM32F429_439xx,ARM_MATH_CM4,__CC_ARM,__FPU_PRESENT = 1,USE_EMBEDDED_PHY,VLAN_FUNC_ENABLE,VLAN_AUTO_ENABLE
  c misc: --diag_suppress=1294,1035
  c include: ..\Micrium\uCOS-II\Source;..\Micrium\uCOS-II\Ports\ARM-Cortex-M4\Generic\RealView;..\User;..\Library\STM32F4xx_StdPeriph_Driver\inc;..\Library\CMSIS\Device\ST\STM32F4xx\Include;..\User\osa;..\User\Driver\LwIP\lwip-1.4.1\src\include;..\User\Driver\LwIP\lwip-1.4.1\src\include\lwip;..\User\Driver\LwIP\lwip-1.4.1\src\include\netif;..\User\Driver\LwIP\lwip-1.4.1\src\include\ipv4;..\User\Driver\LwIP\lwip-1.4.1\port\STM32F4x7;..\User\Driver\LwIP\lwip-1.4.1\port\STM32F4x7\Standalone;..\Library\STM32F4x7_ETH_Driver\inc;..\User\logic\fileload;..\User\logic\fileupdate;..\User\logic\sysfunction;..\User\Server\can;..\User\Server\devicemng;..\User\Server\log;..\User\Server\network\bcm;..\User\Server\network\ipscaner;..\User\Server\network\udp;..\User\UI\MainWin;..\User\UI\ParamWin;..\User\UI\SysSetupWin;..\User\Server\util;..\User\UI\StateWin;..\User\Driver\bsp;..\User\Driver\fatfs;..\User\Driver\LwIP;..\User\Driver\LwIP\inc;..\User\Server\util;..\User\Server\can;..\User\logic\fileload;..\User\logic\fileupdate;..\User\logic\cJson;..\User\Driver\gui\Config;..\User\Driver\gui\GUI_X;..\User\Driver\gui\GUILib;..\User\Driver\gui\lcd;..\User\UI\MainWin;..\User\UI\ParamWin;..\User\UI\StateWin;..\User\UI\SysSetupWin;..\User\Driver\gui\Include;..\User\Driver\Uart;..\User\UI;..\User\Driver\gui\guizk;..\User\PNG;..\User\Server\wireless;..\User\cm_backtrace\fault_handler;..\User\cm_backtrace\fault_handler\keil;..\User\cm_backtrace\Languages\en-US
  library: MicroLIB
  memory RVCT4: ROM 0x8010000 size 0xf0000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group User
    ../User/: main.c includes.h ProjectConfig.h
  group User/OSA
    ../User/: OsEvent.h
    ../User/OSA/: app_cfg.h app_hooks.c
    ../User/osa/: os_api.c
  group Logic/SysFunction
    ../User/logic/sysfunction/: sys_data_mng.c SysFunc_API.c sensor.c part.c alarm.c singleAction.c combAction.c groupAction.c sysParamAnalysis.c
  group Logic/FileLoad
    ../User/logic/fileload/: DoFatfsFiles.c FileLoad.c
  group Logic/FileUpdate
    ../User/logic/fileupdate/: FileUpdate.c
  group Logic/cJson
    ../User/logic/cJson/: cJSON.c Json_Analysis.c
  group Server/Network/udp
    ../User/Server/network/udp/: udp_server.c udp_datalink.c udp_app_bcm.c udp_app_proc.c udp_app_callback.c udp_update_callback.c
  group Server/Network/ipscaner
    ../User/Server/network/ipscaner/: ipscaner.c
  group Server/Network/bcm
    ../User/Server/network/bcm/: bcm8953x_lib.c bcm8953xutil.c
  group Server/Can
    ../User/Server/can/: V2_Can_Pro.c Can_Pro.c Can_Bus.c NativeCan_Driver.c SPICan_Driver.c
  group Server/Devicemng
    ../User/Server/devicemng/: devmng_api.c devmng.c devmng_dev.c
  group Server/Log
    ../User/Server/log/: Log_Data_Mng.c
  group Server/Util
    ../User/Server/util/: chain.c memory.c memory_pool.c crc.c Util_Timer.c Util_CRC.c
  group Server/Wireless
    ../User/Server/wireless/: V4_Wireless.c Wireless_Bus.c IR_Tx.c Wireless_Driver.c IR_Rx.c Wireless_Alarm.c
  group UI/MainWin
    ../User/UI/: GroupTask.c GUI_api.c GUI_Refresh.c HomeConfig.c HomeTask.c MasterContorTask.c MenuTask.c MenuConfig.c SlveContorTask.c StateConfig.c StateTask.c User_Button.c User_GUI.c User_ListView.c User_Text.c DeveloperTask.c RackContorTask.c FollowTask.c ServerMenuConfig.c ServerMenuTask.c RecoilTask.c
  group UI/GUIKey
    ../User/UI/: GUIKey.c
  group UI/GUIzk
    ../User/Driver/gui/guizk/: GUI_FontHZ12.c GUI_FontHZ16.c GUI_FontHZ24.c GUI_FontHZ32.c GUI_UC_EncodeNone.c GUICharPEx.c zik.c fontupd.c left_btn1_hover.c left_btn2_hover.c left_btn3_hover.c right_btn1_hover.c right_btn3_hover.c zik1.c zik2.c
  group Driver/Lwip
    ../User/Driver/LwIP/lwip-1.4.1/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
    ../User/Driver/LwIP/lwip-1.4.1/src/core/: def.c dhcp.c dns.c init.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timers.c udp.c
    ../User/Driver/LwIP/lwip-1.4.1/src/core/ipv4/: autoip.c icmp.c igmp.c inet.c inet_chksum.c ip.c ip_addr.c ip_frag.c
    ../User/Driver/LwIP/lwip-1.4.1/src/netif/: etharp.c
    ../User/Driver/LwIP/: netconf.c
    ../User/Driver/LwIP/lwip-1.4.1/port/STM32F4x7/Standalone/: ethernetif.c
  group Driver/BSP
    ../User/Driver/bsp/: bsp.c bsp_beep.c bsp_fsmc_flash.c bsp_i2c_gpio.c bsp_int.c bsp_iwdg.c bsp_key.c bsp_led.c bsp_mcp2515.c bsp_nand_flash.c bsp_rs485.c bsp_shell.c bsp_spi_551.c bsp_time.c bsp_spi_norflash.c bsp_adc.c bsp_spi_adc.c bsp_rtc.c bsp_spi_bus.c bsp_dwt.c bsp_tim_pwm.c bsp_sdram.c bsp_eeprom_24xx.c bsp_beeps.c bsp_jtbs.c bsp_leds.c
    ../User/Driver/LwIP/: stm32f4x7_eth_bsp.c
  group Driver/Fatfs
    ../User/Driver/fatfs/: diskio.c ff.c malloc.c mycc936.c
  group Driver/Uart
    ../User/Driver/Uart/: timer.c usart.c usartapp.c
  group Driver/LCD
    ../User/Driver/gui/lcd/: bsp_ra8875_flash.c bsp_ra8875_port.c bsp_tft_lcd.c LCD_ILI9488.c LCD_RA8875.c LCD_SPFD5420.c
  group Driver/Gui
    ../User/Driver/gui/Config/: GUIConf.c GUIDRV_Template.c LCDConf_FlexColor_Template.c
    ../User/Driver/gui/GUI_X/: GUI_X_uCOS.c
  group User/Startup
    ../Library/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
    ../Library/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f429_439xx.s
  group LIb/Eth_Driver
    ../Library/STM32F4x7_ETH_Driver/src/: stm32f4x7_eth.c
  group Lib/StdPeriph_Driver
    ../Library/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_fmc.c stm32f4xx_gpio.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_qspi.c stm32f4xx_rcc.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_adc.c stm32f4xx_rtc.c stm32f4xx_pwr.c
  group Lib/DSP_Lib
    ../Library/CMSIS/Lib/ARM/: arm_cortexM4lf_math.lib
  group Lib/emwin
    ../User/Driver/gui/GUILib/: STemWin528_CM4_OS_Keil_ot.lib
  group uC/OSII-Source
    ../Micrium/uCOS-II/Source/: os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c ucos_ii.h
  group uC/OSII-Port
    ../Micrium/uCOS-II/Ports/ARM-Cortex-M4/Generic/RealView/: os_cpu.h os_cpu_a.asm os_cpu_c.c os_dbg.c
  group readme
    ../: readme.txt
  group UI/PNG
    ../User/PNG/: adler32.c compress.c crc32.c deflate.c GUI_PNG.c gzio.c IMAGE_PNG.c infback.c inffast.c inflate.c inftrees.c png.c pngerror.c pnggccrd.c pngget.c pngmem.c pngpread.c pngread.c pngrio.c pngrtran.c pngrutil.c pngset.c pngtrans.c pngvcrd.c pngwio.c pngwrite.c pngwtran.c pngwutil.c trees.c uncompr.c zutil.c
software components: CMSIS:CORE 5.2.0
